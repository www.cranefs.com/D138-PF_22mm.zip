# Autodesk Inventor part: D138_PF-22mm
## iProperties
Created: 2011-08
Part Number: D138_PF-22mm
Document SubType Name: Modeling
Designer: D Cole
Density: 1 g/cm^3
Author: D Cole
